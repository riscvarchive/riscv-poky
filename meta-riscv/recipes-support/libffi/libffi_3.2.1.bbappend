SRCREV_riscv64 = "f3662d621c0e900881b78f6f8989ddc6fae8b1d7"
SRC_URI_riscv64 = "\
     git://github.com/alonamid/libffi-riscv;branch=master;protocol=git \
"
