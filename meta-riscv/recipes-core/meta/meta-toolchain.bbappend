TOOLCHAIN_HOST_TASK += "nativesdk-riscv-fesvr nativesdk-riscv-spike"
