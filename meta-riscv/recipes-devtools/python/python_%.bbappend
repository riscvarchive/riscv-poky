EXTRA_OECONF += "--with-system-ffi --enable-shared"
