FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://gcc-5.2-riscv.patch"
#SRC_URI += "file://gcc-4.9-config.patch"
