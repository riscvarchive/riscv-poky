FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://gcc-6.1-riscv.patch"
#SRC_URI += "file://gcc-4.9-config.patch"
