EXTRA_OECONF += "--disable-libmudflap \
                --disable-libssp \
                --disable-libquadmath \
		--disable-libitm \
                --disable-nls \
                --enable-tls \
                --disable-multilib"
