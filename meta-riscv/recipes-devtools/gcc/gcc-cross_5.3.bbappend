EXTRA_OECONF += "--disable-libmudflap \
                --disable-libssp \
                --disable-libquadmath \
                --disable-nls \
                --enable-tls \
                --disable-multilib"
