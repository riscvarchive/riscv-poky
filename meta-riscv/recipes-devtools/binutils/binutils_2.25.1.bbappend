FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_riscv64 = "file://binutils-2.25.1-riscv.patch"
