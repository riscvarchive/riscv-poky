FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_riscv = "file://binutils-2.24-riscv.patch"
