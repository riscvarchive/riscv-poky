FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://riscv-binutils.patch"
