FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://dpkg-cputable-riscv.patch"
