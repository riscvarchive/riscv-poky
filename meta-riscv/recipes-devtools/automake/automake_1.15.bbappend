FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://automake-update-config-sub-guess-to-706fbe57e39d59f319d338de13b20cecbf7c638c.patch"

